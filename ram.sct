
LR 0x30000000 0x00200000
{
	ER_ROM 0x30000000
	{
		s3c2440.o (RESET, +FIRST)
		* (+RO)
	}

	ER_RW +0
	{
		* (+RW)
		* (+ZI)
	}
}