# Keil uVision project jz2440_ucos.uvproj, settings and files
target jz2440_ucos (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: jz2440_ucos
  c flags: Optim=1
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: ..\..\test_jz2440.sct
  group jz2440_ucos
    ../../: start.S startup.c
