# Keil uVision project test_jz2440.uvproj, settings and files
target test_jz2440 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: test_jz2440
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\..\kernel\rt-thread\include;..\..\..\test_jz2440;..\..\..\..\mcu\s3c2440
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: .\test_jz2440.sct
  group s3c2440
    ../../../../mcu/s3c2440/: start.S
  group rt-thread
    ../../../../kernel/rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group test_jz2440
    ../../: main.c context.S interrupt.c rtconfig.h stack.c
