


LR 0x0 
{
	ER_ROM 0x0 0x00020000
	{
		start.o (RESET, +FIRST)
		* (+RO)
	}

	

}