# Keil uVision project jz2440_ucos_iii.uvproj, settings and files
target jz2440_ucos_iii (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: jz2440_ucos_iii
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT9: RAM 0x40000000 size 0x1000
