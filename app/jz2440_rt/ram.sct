
LR 0x30000000 0x00200000
{
	ER_ROM 0x30000000
	{
		start.o (RESET, +FIRST)
		* (+RO)
	}

	ER_RW +0
	{
		* (+RW)
		* (+ZI)
	}
}