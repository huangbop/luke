# Keil uVision project jz2440_rt.uvproj, settings and files
target jz2440_rt (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: jz2440_rt
  c flags: Optim=1
  c include: ..\..\..\..\kernel\rt-thread\include;..\..\..\jz2440_rt
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: ..\..\ram.sct
  group s3c2440
    ../../../../mcu/s3c2440/: uart.c s3c2440_clock.c
  group jz2440
    ../../../../board/jz2440/: board.c
  group rt_thread
    ../../../../kernel/rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group jz2440_rt
    ../../: application.c start.S startup.c context.S stack.c console.c
